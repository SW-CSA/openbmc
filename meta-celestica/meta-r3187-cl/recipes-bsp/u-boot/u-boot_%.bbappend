FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-support-dual-bootsource.patch \
            file://0001-change-baud-rate-to-115200.patch \
           "

SERIAL_CONSOLES = "115200;ttyS0"
